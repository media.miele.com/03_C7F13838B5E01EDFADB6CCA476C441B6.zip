Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 86170101-1ae0-466b-a7a6-fecc01d6523b, NumberOfSaves: 1]
File name: 0001
Time: 2024-12-03T08:51:10+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12699270_GB_TQ1000WP_LW:12Q10001_GB_12699270_TQ1000WP_LW, (2)
In: Default
Type - Material: z_Miele_Design_CLST, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Connection_Connection_Modul, z_Miele_Connection_AW
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 643 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 12Q10001_GB_12699270_TQ1000WP_LW; sets with these values: 2
